# Keil uVision project magic_stick.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: magic_stick +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\SRC;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\Core\CM3;.\Libraries\Fusion;.\mcu_sdk;..\USER;.\BOARD
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group SRC
    ./SRC/: main.c stm32f10x_it.c MPU9250.c Obj_state.c Uart.c Myqueue.c Timer.c
  group LIB
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c misc.c stm32f10x_gpio.c stm32f10x_flash.c
  group STARTUP
    ./Libraries/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_hd.s
  group CM3
    ./Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group TP_LIB
    ./Libraries/Fusion/: FusionAhrs.c FusionBias.c FusionCompass.c
  group MCU
    ./mcu_sdk/: mcu_api.c protocol.c system.c
  group BOARD
    ./BOARD/: Hal_Key.c Hal_RGB.c
software components: CMSIS:CORE 5.5.0
